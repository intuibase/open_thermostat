## sdkconfig.defaults
```kconfig
CONFIG_BT_ENABLED=y
CONFIG_BLUEDROID_ENABLED=n
CONFIG_BT_CLASSIC_ENABLED=n
CONFIG_BT_BLE_ENABLED=y
```
